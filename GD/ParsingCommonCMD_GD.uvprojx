# Keil uVision project ParsingCommonCMD_GD.uvprojx, settings and files
target User (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ParsingCommonCMD_GD
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User\Drivers\CMSIS\Device\Include;.\User\Drivers\CMSIS\Include;.\User\Drivers\GD32F10x_\Include;.\User\Core\Inc;..\..\CAN\common\Inc;..\..\FLASH\common\Inc;..\..\CAN\CAN_GD32F103R\Core\Inc;..\..\FLASH\GD_Flash\User\Inc;..\common\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Core
    ./User/Core/Src/: main.c gd32f10x_it.c
    ../common/Src/: commonCMD.c
    ../../CAN/common/Src/: CAN.c
    ../../FLASH/common/Src/: FLASH.c
    ../../CAN/CAN_GD32F103R/Core/Src/: CAN_GD32F103R.c
    ../../FLASH/GD_Flash/User/Src/: GD_flash.c
  group Drivers
    ./User/Drivers/CMSIS/Device/Source/: startup_gd32f10x_hd.s system_gd32f10x.c
    ./User/Drivers/GD32F10x_/Source/: gd32f10x_misc.c gd32f10x_fmc.c systick.c
